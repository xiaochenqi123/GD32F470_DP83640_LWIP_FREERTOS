# Keil uVision project GD32F470_Freertos.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARM_Complier_5.05_uv7)
  device: GD32F470VK GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.2.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0300000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F470_Freertos +hex
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F470
  c include: ..\User;..\Firmware\CMSIS;..\Firmware\CMSIS\GD\GD32F4xx\Include;..\Firmware\GD32F4xx_standard_peripheral\Include;..\Thirdparty\FreeRtos\include;..\Thirdparty\FreeRtos\portable\MemMang;..\Thirdparty\FreeRtos\portable\RVDS\ARM_CM4F;..\Hardware\DP83640\inc;..\Thirdparty\Lwip\src\include;..\Thirdparty\Lwip\src\include\lwip;..\Thirdparty\Lwip\src\include\netif;..\Thirdparty\Lwip\port\GD32F4xx;..\Thirdparty\Lwip\port\GD32F4xx\FreeRTOS;..\Hardware\DP83640\src;..\App;..\Thirdparty\FreeRtos\CMSIS_RTOS;..\Thirdparty\Lwip\port\GD32F4xx\arch;..\Thirdparty\Lwip\src\include\lwip;..\Thirdparty\PTPd\src;..\Thirdparty\PTPd\src\dep
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: gd32f4xx_it.c main.c systick.c
  group Firmware
    ../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group CMSIS
    ../Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
    ../Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group Doc
    ../Doc/: readme.txt
  group App
    ../App/: netconf.c hello_gigadevice.c tcp_client.c udp_echo.c lwip.c gd32f4xx_dp83640.c
    ../User/: gd32f4xx_enet_eval.c
  group port
    ../Thirdparty/FreeRtos/portable/MemMang/: heap_4.c
    ../Thirdparty/FreeRtos/portable/RVDS/ARM_CM4F/: port.c
  group FreeRtos
    ../Thirdparty/FreeRtos/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group DP83640
    ../Hardware/DP83640/src/: epl_1588.c epl_core.c epl_oai.c
  group Lwip
    ../Thirdparty/Lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Thirdparty/Lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../Thirdparty/Lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../Thirdparty/Lwip/src/netif/: ethernet.c
  group Lwip_port
    ../Thirdparty/Lwip/port/GD32F4xx/FreeRTOS/: ethernetif.c sys_arch.c
